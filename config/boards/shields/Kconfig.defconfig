## config/boards/shields/Kconfig.defconfig
```kconfig
if SHIELD_HAMMERHEAD38

config ZMK_KEYBOARD_NAME
    default "hammerhead"

endif
```
